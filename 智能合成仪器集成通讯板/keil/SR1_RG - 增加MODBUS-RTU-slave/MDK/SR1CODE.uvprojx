# Keil uVision project SR1CODE.uvprojx, settings and files
target SR1CODE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SR1CODE
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Driver;..\Library;..\Library\Core;..\Library\inc;..\Library\src;..\USER;..\Driver\SysTick;..\Driver\CAN;..\Driver\HighPressureValve;..\Driver\RS232;..\Driver\rs485;..\Driver\FreeModbus\ascii;..\Driver\FreeModbus\functions;..\Driver\FreeModbus\include;..\Driver\FreeModbus\port;..\Driver\FreeModbus\rtu;..\Driver\FreeModbus\tcp;..\Driver\FreeModbus
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Library/: system_stm32f10x.c
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group Core
    ../Library/Core/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group Include
    ../Library/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Library/: system_stm32f10x.h stm32f10x.h
  group Driver
    ../Driver/CAN/: can1_app.c
    ../Driver/HighPressureValve/: mrv01_app.c mrv01_app.h
    ../Driver/SysTick/: SysTick.c SysTick.h
    ../Driver/RS232/: rs232_usart3_app.c
  group Modbus
    ../Driver/FreeModbus/: mb.c user_mb_app.c
    ../Driver/FreeModbus/rtu/: mbcrc.c mbrtu.c
    ../Driver/FreeModbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Driver/FreeModbus/port/: portevent.c portserial.c porttimer.c
    ../Driver/FreeModbus/ascii/: mbascii.c
    ../Driver/FreeModbus/tcp/: mbtcp.c
